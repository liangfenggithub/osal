# IAR project Newbit-OSAL-Demo.ewp, settings and files
configuration newbit_arduino_demo (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: HAL_LCD=TRUE; LCD_SUPPORTED; ZAPP_P1; HAL_KEY=TRUE; ARDUINO=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\Components\hal\include; ..\..\Components\hal\target\common; ..\..\Components\hal\target\newbit; ..\..\Components\osal\include; ..\..\Components\cul\; ..\..\Components\FileSystem\; ..\main\; $TOOLKIT_DIR$\src\lib\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\Tools\newbit\f8w2530.xcl
configuration NBTEST_KIT_4 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: HAL_LCD=TRUE; LCD_SUPPORTED; ZAPP_P1; HAL_KEY=TRUE; NBTEST_KIT_4=TRUE
configuration AD_SENSOR (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: HAL_LCD=TRUE; LCD_SUPPORTED; ZAPP_P1; HAL_KEY=TRUE; AD_SENSOR=TRUE
  group app
    ../Utilities/BaseApp/Source/: adSensorDemo.c adSensorDemo.h Arduino.c Arduino.h BaseApp.c BaseApp.h nbTest.c nbTest.h onebusDemo.c onebusDemo.h OSAL_BaseApp.c
  group cul
    ../../Components/cul/: ul_crc.c ul_strings.c
  group FS
    ../../Components/FileSystem/: FS_HighLevel.c FS_Lowlevel.c FS_Lowlevel.h
  group hal/common
    ../../Components/hal/common/: hal_assert.c hal_drivers.c
  group hal/target/cc2530
    ../../Components/hal/target/common/: hal_adc.c hal_dma.c hal_flash.c hal_mcu.c hal_sleep.c
  group hal/target/newbit/drivers
    ../../Components/hal/target/newbit/: font.c hal_dht11.c hal_eFlash.c hal_key.c hal_led.c hal_oled_spi.c hal_startup.c hal_timer.c hal_timer34.c hal_uart.c
  group main
    ../Main/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
  group osal
    ../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../Components/osal/mcu/cc2530/: OSAL_Nv.c OSAL_SleepTimer.c
  group Tools
    ../Tools/newbit/: f8w2530.xcl
